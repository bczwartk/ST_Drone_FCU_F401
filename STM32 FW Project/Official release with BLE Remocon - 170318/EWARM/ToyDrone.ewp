# IAR project ToyDrone.ewp, settings and files
configuration cpptest (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401VC ST STM32F401VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xC; DEBUG
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Drivers\BSP\Board; ..\Drivers\BSP\Components\lsm6ds33; ..\Drivers\BSP\Components\lis3mdl; ..\Drivers\BSP\Components\lps25hb; ..\Drivers\BSP\Components\Common; ..\Drivers\BSP\Components\lsm6dsl; ..\Drivers\BSP\Components\lps22hb; ..\Drivers\BSP\Components\lsm303agr; ..\Drivers\BSP\STEVAL_FCU001_V1; ..\Drivers\BSP\Components\lis2mdl; ..\Drivers\BlueNRG; ..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\Drivers\BSP\Components\spbtlerf
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DroneKit_301018_official.hex
  ILINK.IlinkOutputFile: ToyDrone Configuration.out
  ILINK.IlinkIcfFile: stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ToyDrone Configuration (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xc.s
  group Application/User
    ../Src/: ahrs.c basic_math.c console.c debug.c flight_control.c main.c motor.c quaternion.c rc.c sensor_data.c sensor_service.c stm32f4xx_hal_msp.c stm32f4xx_it.c timer.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Drivers/Board
    ../Drivers/BSP/STEVAL_FCU001_V1/: steval_fcu001_v1.c steval_fcu001_v1_accelero.c steval_fcu001_v1_gyro.c steval_fcu001_v1_magneto.c steval_fcu001_v1_pressure.c steval_fcu001_v1_temperature.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/Components
    ../Drivers/BSP/Components/lis2mdl/: LIS2MDL_MAG_driver.c LIS2MDL_MAG_driver_HL.c
    ../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ../Drivers/BSP/Components/spbtlerf/: SPBTLE_RF.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Middlewares/STM32_BlueNRG/HCI
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/STM32_BlueNRG/HCI/Controller
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils.c
  group Middlewares/STM32_BlueNRG/Interface
    ../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
  group Middlewares/STM32_BlueNRG/Utils
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
